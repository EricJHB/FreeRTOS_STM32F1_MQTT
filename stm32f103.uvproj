# Keil uVision project stm32f103.uvproj, settings and files
target STM32F103 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103 +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\core;.\fwlib\inc;.\hardware\inc;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\user;.\NET\device\inc;.\NET\protocol\inc;.\MQTT
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ./core/: core_cm3.c system_stm32f10x.c stm32f10x_it.c
    ./core/startup/arm/: startup_stm32f10x_hd.s
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_tim.c
  group hardware
    ./hardware/src/: led.c delay.c key.c usart.c adxl345.c i2c.c sht20.c iwdg.c at24c02.c selfcheck.c gy30.c beep.c oled.c hwtimer.c info.c adc.c tcrt5000.c lcd1602.c
  group user
    ./user/: main.c freertosAPI.c
  group MQTT
    ./MQTT/: mqtt.c mqtt_app.c mqtt_buffer.c
  group net_protocol
    ./NET/protocol/src/: fault.c onenet.c
  group net_device
    ./NET/device/src/: net_io.c net_device.c
